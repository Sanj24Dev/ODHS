# IAR project mpu6050.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F4XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\Parikshit\Peripheral drivers\Primary\MPU6050 - gyro; D:\Parikshit\Peripheral drivers\library\CPAL lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group device
    ../../library/CPAL lib/src/basic/: cpal_i2c_hal_stm32f4xx.c startup_stm32f4xx.s stm32_eval_i2c_ee_cpal.c system_stm32f4xx.c
    ../../library/CPAL lib/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c
  group cpal
    ../../library/CPAL lib/src/basic/: cpal_hal.c cpal_i2c.c cpal_usercallback.c
  group user
    ./: gyro.c main.c
